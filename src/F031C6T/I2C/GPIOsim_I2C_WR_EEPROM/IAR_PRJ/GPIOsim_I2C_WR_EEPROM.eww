<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\GPIOsim_I2C_WR_EEPROM.ewp</path>
  </project>
  <batchBuild/>
</workspace>


