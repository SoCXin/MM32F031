<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>D:\MT53\MT53\software\main\IAR\MT53.ewp</path>
    </project>
    <batchBuild />
</workspace>
