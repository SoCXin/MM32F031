# Keil uVision project ADC_BasicExample.uvprojx, settings and files
target project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MM32F031C8T MindMotion
  pack: MindMotion.MM32F031_DFP.1.3.7
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: output +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER  MM32F031NVERSION
  c include: ..\SYSTEM\delay;..\SYSTEM\uart;..\SYSTEM\sys;..\HARDWARE\LED;..\..\..\..\..\Device\CMSIS\KEIL_CORE;..\HARDWARE\ADC;..\..\..\..\..\Device\MM32F031xxn\HAL_lib\inc;..\..\..\..\..\Device\MM32F031xxn\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group STARTUP
    ../../../../../Device/MM32F031xxn/Source/: system_MM32F031xxn.c
    ../../../../../Device/MM32F031xxn/Source/KEIL_StartAsm/: startup_MM32F031xxn_KEIL.s
  group HALlib
    ../../../../../Device/MM32F031xxn/HAL_lib/src/: HAL_adc.c HAL_bkp.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_spi.c HAL_syscfg.c HAL_tim.c HAL_uart.c HAL_wwdg.c
  group USER
    ../USER/: main.c
  group SYSTEM
    ../SYSTEM/UART/: uart.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/ADC/: adc.c
  group README
    ../: README.TXT
