# Keil uVision project project.uvprojx, settings and files
target Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MM32F031C6T MindMotion
  pack: MindMotion.MM32F031_DFP.1.4.0
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Debug +hex
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER  MM32F031NVERSION DEBUG
  c include: ..\..\..\Device\CMSIS\KEIL_CORE;..\..\..\Device\MM32F031x4x6\Include;..\..\..\Device\MM32F031x4x6\HAL_lib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group USER
    ../USER/: main.c
  group HALlib
    ../../../Device/MM32F031x4x6/HAL_lib/src/: HAL_adc.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_spi.c HAL_syscfg.c HAL_tim.c HAL_uart.c HAL_wwdg.c
  group STARTUP
    ../../../Device/MM32F031x4x6/Source/: system_MM32F031x4x6_q.c
    ../../../Device/MM32F031x4x6/Source/KEIL_StartAsm/: startup_MM32F031x4x6_q.s
target Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MM32F031C6T MindMotion
  pack: MindMotion.MM32F031_DFP.1.4.0
  cpu: as above
  output: MM32 +hex
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER  MM32F031NVERSION
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
target STLINK (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MM32F031C6T MindMotion
  pack: MindMotion.MM32F031_DFP.1.4.0
  cpu: as above
  output: Debug +hex
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER  MM32F031NVERSION DEBUG
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
target MMLINK (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MM32F031C6T MindMotion
  pack: MindMotion.MM32F031_DFP.1.4.0
  cpu: as above
  output: Debug +hex
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER  MM32F031NVERSION DEBUG
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
target JLink (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MM32F031C6T MindMotion
  pack: MindMotion.MM32F031_DFP.1.4.0
  cpu: as above
  output: Debug +hex
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER  MM32F031NVERSION DEBUG
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
